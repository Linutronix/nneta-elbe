inherit elbeimage

PN = "simple-image"
IMAGE_INSTALL += "bash vim-nox"
