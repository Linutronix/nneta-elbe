# Copyright (C) 2018 Torben Hohn <torben.hohn@linutronix.de>
# Released under the MIT license (see COPYING.MIT for the terms)

inherit initvm

LICENSE="MIT"
